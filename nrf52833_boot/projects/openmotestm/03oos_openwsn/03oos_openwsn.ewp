# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\openmotestm\configure\; ..\..\..\bsp\boards\openmotestm\library\inc\; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\openmotestm\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\OpenwsnHeads\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\cjoin\; ..\..\..\openapps\opencoap\; ..\..\..\openapps\uecho\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\rrt\; ..\..\..\openapps\uinject\; ..\..\..\openapps\userialbridge\; ..\..\..\openapps\uexpiration\; ..\..\..\openapps\uexpiration_monitor\; ..\..\..\openapps\cexample\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 03oos_openwsn.srec
  ILINK.IlinkOutputFile: 03oos_openwsn.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h sctimer.h uart.h
  group bsp/boards/openmotestm
    ../../../bsp/boards/openmotestm/: board.c board_info.h cryptoengine.c debugpins.c eui64.c flash.c flash.h i2c.c i2c.h leds.c nvic.c nvic.h rcc.c rcc.h sctimer.c spi.c uart.c
  group bsp/boards/openmotestm/configure
    ../../../bsp/boards/openmotestm/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/openmotestm/ewarm
    ../../../bsp/boards/openmotestm/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/openmotestm/lib
    ../../../bsp/boards/openmotestm/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
  group openapps
    ../../../openapps/: openapps.c
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c c6t.h
  group openapps/cexample
    ../../../openapps/cexample/: cexample.c cexample.h
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c cinfo.h
  group openapps/cjoin
    ../../../openapps/cjoin/: cjoin.c cjoin.h cojp_cbor.c cojp_cbor.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c cleds.h
  group openapps/cstorm
    ../../../openapps/cstorm/: cstorm.c cstorm.h
  group openapps/cwellknown
    ../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group openapps/opencoap
    ../../../openapps/opencoap/: cborencoder.c cborencoder.h hkdf.c hmac.c opencoap.c opencoap.h oscore.c oscore.h sha-private.h sha.h sha224-256.c usha.c
  group openapps/rrt
    ../../../openapps/rrt/: rrt.c rrt.h
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c uecho.h
  group openapps/uexpiration
    ../../../openapps/uexpiration/: uexpiration.c uexpiration.h
  group openapps/uinject
    ../../../openapps/uinject/: uinject.c uinject.h
  group openapps/userialbridge
    ../../../openapps/userialbridge/: userialbridge.c userialbridge.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154_security.c IEEE802154_security.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: msf.c msf.h neighbors.c neighbors.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openstack/03b-IPV6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: openudp.c openudp.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
