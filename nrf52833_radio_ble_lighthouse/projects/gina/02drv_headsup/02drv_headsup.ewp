# IAR project 02drv_headsup.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\; ..\..\..\bsp\boards\gina\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\drivers\common\; ..\..\..\drivers\gina\; ..\..\..\inc\; ..\..\..\kernel\; ..\..\..\openstack\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: 02drv_headsup.c
  group bsp/boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h uart.h
  group bsp/boards/gina
    ../../../bsp/boards/gina/: board.c board_info.h debugpins.c eui64.c i2c.c leds.c sctimer.c spi.c uart.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers
    ../../../drivers/common/: opentimers.c opentimers.h
  group drivers/gina
    ../../../drivers/gina/: sensitive_accel_temperature.c sensitive_accel_temperature.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/: scheduler.h
    ../../../kernel/openos/: scheduler.c
