# IAR project 02drv_opentimers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\openmotestm\configure\; ..\..\..\bsp\boards\openmotestm\library\inc\; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\openmotestm\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\OpenwsnHeads\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openapps\; ..\..\..\openapps\bbk\; ..\..\..\openapps\heli\; ..\..\..\openapps\imu\; ..\..\..\openapps\layerdebug\; ..\..\..\openapps\rleds\; ..\..\..\openapps\rreg\; ..\..\..\openapps\rwellknown\; ..\..\..\openapps\rt\; ..\..\..\openapps\rex\; ..\..\..\openapps\rinfo\; ..\..\..\openapps\rheli\; ..\..\..\openapps\rxl1\; ..\..\..\openapps\rrube\; ..\..\..\openapps\ohlone\; ..\..\..\openapps\tcpecho\; ..\..\..\openapps\tcpinject\; ..\..\..\openapps\tcpprint\; ..\..\..\openapps\udpecho\; ..\..\..\openapps\udpinject\; ..\..\..\openapps\udplatency\; ..\..\..\openapps\udpprint\; ..\..\..\openapps\udprand\; ..\..\..\openapps\udpstorm\; ..\..\..\openstack\cross-layers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 02drv_opentimer.srec
  ILINK.IlinkOutputFile: 02drv_opentimer.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\boards\openmotestm\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/02drv_opentimers/: 02drv_opentimers.c
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h sctimer.h uart.h
  group bsp/boards/openmotestm
    ../../../bsp/boards/openmotestm/: board.c board_info.h cryptoengine.c debugpins.c eui64.c flash.c flash.h i2c.c i2c.h leds.c nvic.c nvic.h rcc.c rcc.h sctimer.c spi.c uart.c
  group bsp/boards/openmotestm/configure
    ../../../bsp/boards/openmotestm/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/openmotestm/ewarm
    ../../../bsp/boards/openmotestm/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/openmotestm/lib
    ../../../bsp/boards/openmotestm/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers
    ../../../drivers/common/: opentimers.c opentimers.h
  group kernel
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
